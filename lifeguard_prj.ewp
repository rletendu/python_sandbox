# IAR project lifeguard_prj.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: __lifeguard__; __PIC32CM5164LS00100__; __DESIGN__; PORT_NEW_API
  ICCARM.CCIncludePath2: ../; ../; ../coremark; ../../../_common/headers; ../../../_common/headers/public; ../../../_common/cmsis; ../../../_common/utils; ../../../_common/drivers/port; ../../../_common/drivers/dmac; ../../../_common/drivers/delay; ../../../_common/utils/preprocessor; ../../../_common/utils/startup
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: lifeguard_prj.bin
  ILINK.IlinkOutputFile: lifeguard.elf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration DummyConf (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: __lifeguard__; __PIC32CM5164LS00100__; __DESIGN__; PORT_NEW_API; DUMMY_DEFINE
  group (top)
    ../: main.c serial_debug.c
    ../../../_common/link/iar/: startup_pic32cmls00.c
